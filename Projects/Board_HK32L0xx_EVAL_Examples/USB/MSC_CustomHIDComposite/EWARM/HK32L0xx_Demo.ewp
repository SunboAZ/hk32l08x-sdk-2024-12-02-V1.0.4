# IAR project HK32L0xx_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HK32L084KBT6 HSXP-HK HK32L084KBT6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Libraries\HK32L0xx_StdPeriphDriver\inc; ..\..\..\..\..\Libraries\CMSIS\HK32L0xx\Include; ..\..\..\..\..\Libraries\CMSIS\CM0\Core; ..\..\..\..\..\Boards\Board_HK32L0xx_EVAL; ..\..\..\..\..\Libraries\HK32L0xx-USB-FS-Device-Driver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HK32L0xx_Demo.srec
  ILINK.IlinkOutputFile: HK32L0xx_Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Board
    ../../../../../Boards/Board_HK32L0xx_EVAL/: hk32l0xx_eval.c
  group Doc
    ../: Readme.txt
  group Library
    ../../../../../Libraries/HK32L0xx_StdPeriphDriver/src/: hk32l0xx_adc.c hk32l0xx_aes.c hk32l0xx_beep.c hk32l0xx_can.c hk32l0xx_clu.c hk32l0xx_comp.c hk32l0xx_crc.c hk32l0xx_dac.c hk32l0xx_dbgmcu.c hk32l0xx_divsqrt.c hk32l0xx_dma.c hk32l0xx_eeprom.c hk32l0xx_emacc.c hk32l0xx_exti.c hk32l0xx_flash.c hk32l0xx_gpio.c hk32l0xx_i2c.c hk32l0xx_irtim.c hk32l0xx_iwdg.c hk32l0xx_lcd.c hk32l0xx_lpuart.c hk32l0xx_misc.c hk32l0xx_opamp.c hk32l0xx_pwr.c hk32l0xx_rcc.c hk32l0xx_rtc.c hk32l0xx_spi.c hk32l0xx_syscfg.c hk32l0xx_tim.c hk32l0xx_trng.c hk32l0xx_usart.c hk32l0xx_wwdg.c
  group Startup
    ../../../../../Libraries/CMSIS/HK32L0xx/Source/IAR/: IAR_Startup_hk32l0xx.s
  group USB_FS_Device_Driver
    ../../../../../Libraries/HK32L0xx-USB-FS-Device-Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group User
    ../src/: hk32l0xx_it.c hw_config.c main.c mass_mal.c memory.c scsi_data.c spi_flash.c usb_bot.c usb_desc.c usb_endp.c usb_istr.c usb_prop.c usb_pwr.c usb_scsi.c
    ../../../../../Libraries/CMSIS/HK32L0xx/Source/: system_hk32l0xx.c
