# IAR project HK32L0xx_Demo.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: HK32L084KBT6 HSXP-HK HK32L084KBT6
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 34
  General.FPU2: 0
  ICCARM.CCDefines: USE_HK32L0XX_EVAL; AES_TWO_BOARD_A
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\..\..\Libraries\HK32L0xx_StdPeriphDriver\inc; ..\..\..\..\..\Libraries\CMSIS\HK32L0xx\Include; ..\..\..\..\..\Libraries\CMSIS\CM0\Core; ..\..\..\..\..\Boards\Board_HK32L0xx_EVAL
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: HK32L0xx_Demo.srec
  ILINK.IlinkOutputFile: HK32L0xx_Demo.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration HK32L0XX_Boards_B (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: USE_HK32L0XX_EVAL; AES_TWO_BOARD_B
  group Board
    ../../../../../Boards/Board_HK32L0xx_EVAL/: hk32l0xx_eval.c
  group Doc
    ../: Readme.txt
  group Library
    ../../../../../Libraries/HK32L0xx_StdPeriphDriver/src/: hk32l0xx_adc.c hk32l0xx_aes.c hk32l0xx_beep.c hk32l0xx_can.c hk32l0xx_clu.c hk32l0xx_comp.c hk32l0xx_crc.c hk32l0xx_dac.c hk32l0xx_dbgmcu.c hk32l0xx_divsqrt.c hk32l0xx_dma.c hk32l0xx_eeprom.c hk32l0xx_emacc.c hk32l0xx_exti.c hk32l0xx_flash.c hk32l0xx_gpio.c hk32l0xx_i2c.c hk32l0xx_irtim.c hk32l0xx_iwdg.c hk32l0xx_lcd.c hk32l0xx_lpuart.c hk32l0xx_misc.c hk32l0xx_opamp.c hk32l0xx_pwr.c hk32l0xx_rcc.c hk32l0xx_rtc.c hk32l0xx_spi.c hk32l0xx_syscfg.c hk32l0xx_tim.c hk32l0xx_trng.c hk32l0xx_usart.c hk32l0xx_wwdg.c
  group Startup
    ../../../../../Libraries/CMSIS/HK32L0xx/Source/IAR/: IAR_Startup_hk32l0xx.s
  group User
    ../src/: aes_util.c hk32l0xx_it.c main.c
    ../../../../../Libraries/CMSIS/HK32L0xx/Source/: system_hk32l0xx.c
