# Keil uVision project HK32L0xx_Demo.uvprojx, settings and files
target HK32L0xx_Demo (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: HK32L084RBT6 HK_MicroChip
  pack: HKMicroChip.HK32L0xx_DFP.1.0.9
  cpu: IRAM(0x20000000,0x05000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: HK32L0xx_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HK32L0XX_EVAL,AES_TWO_BOARD_A
  c include: ..\inc;..\..\..\..\..\Libraries\HK32L0xx_StdPeriphDriver\inc;..\..\..\..\..\Libraries\CMSIS\CM0\Core;..\..\..\..\..\Libraries\CMSIS\HK32L0xx\Include;..\..\..\..\..\Boards\Board_HK32L0xx_EVAL
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ../../../../../Libraries/CMSIS/HK32L0xx/Source/ARM/: KEIL_Startup_hk32l0xx.s
  group Src
    ../src/: main.c aes_util.c hk32l0xx_it.c
    ../../../../../Libraries/CMSIS/HK32L0xx/Source/: system_hk32l0xx.c
  group HK32L0xx_lib
    ../../../../../Libraries/HK32L0xx_StdPeriphDriver/src/: hk32l0xx_adc.c hk32l0xx_aes.c hk32l0xx_beep.c hk32l0xx_can.c hk32l0xx_clu.c hk32l0xx_comp.c hk32l0xx_crc.c hk32l0xx_dac.c hk32l0xx_dbgmcu.c hk32l0xx_divsqrt.c hk32l0xx_dma.c hk32l0xx_eeprom.c hk32l0xx_emacc.c hk32l0xx_exti.c hk32l0xx_flash.c hk32l0xx_gpio.c hk32l0xx_i2c.c hk32l0xx_irtim.c hk32l0xx_iwdg.c hk32l0xx_lcd.c hk32l0xx_lpuart.c hk32l0xx_misc.c hk32l0xx_opamp.c hk32l0xx_pwr.c hk32l0xx_rcc.c hk32l0xx_rtc.c hk32l0xx_spi.c hk32l0xx_syscfg.c hk32l0xx_tim.c hk32l0xx_trng.c hk32l0xx_usart.c hk32l0xx_wwdg.c
  group Boards
    ../../../../../Boards/Board_HK32L0xx_EVAL/: hk32l0xx_eval.c
  group Doc
    ../: Readme.txt Expected_Results_BoardA.txt Expected_Results_BoardB.txt
target HK32L0xx_Boards_B (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: HK32L084RBT6 HK_MicroChip
  pack: HKMicroChip.HK32L0xx_DFP.1.0.9
  cpu: as above
  output: HK32L0XX_Boards_B +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_ASSERT,USE_HK32L0XX_EVAL,AES_TWO_BOARD_B
  c include: ..\..\..\..\..\Libraries\CMSIS\CM0\Core;..\..\..\..\..\Libraries\CMSIS\HK32L0xx\Include;..\..\..\..\..\Libraries\HK32L0xx_StdPeriphDriver\inc;..\..\..\..\..\Boards\Board_HK32L0xx_EVAL;..\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
